<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\intreruperi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\seriala_intrerupere.ewp</path>
  </project>
  <batchBuild/>
</workspace>


