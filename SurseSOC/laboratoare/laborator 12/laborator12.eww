<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\perioada_cu_intreruperi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\perioadaSemnal.ewp</path>
  </project>
  <batchBuild/>
</workspace>


