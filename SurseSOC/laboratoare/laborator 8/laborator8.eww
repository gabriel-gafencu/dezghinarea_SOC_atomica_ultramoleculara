<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\problema1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\problema2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\problema3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


