<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CRC_XXXX_YYYY.ewp</path>
  </project>
  <batchBuild/>
</workspace>


