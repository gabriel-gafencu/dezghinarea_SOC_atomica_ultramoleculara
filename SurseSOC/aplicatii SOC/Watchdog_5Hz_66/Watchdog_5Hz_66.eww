<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Watchdog_5Hz_66.ewp</path>
  </project>
  <batchBuild/>
</workspace>


