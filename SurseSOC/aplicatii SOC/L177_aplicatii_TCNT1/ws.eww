<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\L175_1kHz_DC_50%_TCNT1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


