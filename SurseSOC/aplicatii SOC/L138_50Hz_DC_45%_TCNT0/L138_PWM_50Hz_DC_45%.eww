<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\L138_PWM_50Hz_DC_45%.ewp</path>
  </project>
  <batchBuild/>
</workspace>


