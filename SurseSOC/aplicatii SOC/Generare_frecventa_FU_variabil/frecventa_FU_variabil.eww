<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\frecventa_FU_variabil.ewp</path>
  </project>
  <batchBuild/>
</workspace>


