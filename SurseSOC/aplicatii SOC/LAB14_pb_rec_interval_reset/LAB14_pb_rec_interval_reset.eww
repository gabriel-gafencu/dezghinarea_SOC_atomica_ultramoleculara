<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LAB14_pb_rec_interval_reset.ewp</path>
  </project>
  <batchBuild/>
</workspace>


